# Keil uVision project Human Heart and Body Temperature Monitor.uvprojx, settings and files
target Human Heart and Body Temperature Monitor (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Human Heart and Body Temperature Monitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App;../App/config;../App/acquisition;../App/buttons;../App/diagnostics;../App/display;../App/ecg;../App/protocol;../App/rtc_service;../App/temperature;../App/ui;../ThirdParty/kk_ui/include;../ThirdParty/kk_ui/src;../ThirdParty/kk_oled/include;../ThirdParty/kk_oled/graphics;../ThirdParty/kk_oled/driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/App
    ../App/acquisition/: acquisition.c
    ../App/: app.c
    ../App/buttons/: buttons.c
    ../App/diagnostics/: diagnostics.c
    ../App/display/: oled_bus.c
    ../App/ecg/: ecg_hr.c ecg_signal.c
    ../App/protocol/: crc16.c protocol.c protocol_service.c
    ../App/rtc_service/: rtc_calendar.c rtc_service.c
    ../App/temperature/: temperature.c
    ../App/uart/: uart_link.c
    ../App/ui/: ui_app.c ui_fonts.c
  group ThirdParty/kk_ui
    ../ThirdParty/kk_ui/src/: kk_ui.c kk_ui_anim.c kk_ui_dialog.c kk_ui_draw.c kk_ui_home.c kk_ui_menu.c kk_ui_nav.c kk_ui_page.c
  group ThirdParty/kk_oled
    ../ThirdParty/kk_oled/graphics/: kk_oled.c kk_oled_bitmap.c kk_oled_draw.c kk_oled_font.c
    ../ThirdParty/kk_oled/driver/: kk_oled_driver.c
software components: CMSIS:CORE 4.3.0
